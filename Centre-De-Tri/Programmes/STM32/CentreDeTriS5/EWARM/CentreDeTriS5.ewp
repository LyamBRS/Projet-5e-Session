# IAR project CentreDeTriS5.ewp, settings and files
configuration CentreDeTriS5 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: CentreDeTriS5.hex
  ILINK.IlinkOutputFile: CentreDeTriS5.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/INTERFACES
    ../Src/: interfaceB1.c interfaceB1.h interfaceT1.c interfaceT1.h interfaceT2.c interfaceT2.h interfaceT3.c interfaceT3.h interfaceT4.c interfaceT4.h
  group Application/User/PILOTES
    ../Src/: piloteCAN1.c piloteCAN1.h piloteI2C.c piloteI2C.h piloteIOB1.c piloteIOB1.h piloteIOT1.c piloteIOT1.h piloteIOT2.c piloteIOT2.h piloteIOT3.c piloteIOT3.h piloteIOT4.c piloteIOT4.h
  group Application/User/PROCESSUS
    ../Src/: processusPasserelle.c
  group Application/User/SERVICES
    ../Src/: serviceBaseDeTemps.c serviceBaseDeTemps.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
